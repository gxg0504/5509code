# Keil uVision project 5509main_board.uvprojx, settings and files
target 5509main_board (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC54608J512BD208:M4 NXP
  pack: Keil.LPC54000_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: host_msd_fatfs_freertos.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: _DEBUG=1, DEBUG, CPU_LPC54608, USB_STACK_FREERTOS, PRINTF_ADVANCED_ENABLE=1, CPU_LPC54608J512ET180=1, USB_STACK_FREERTOS_HEAP_SIZE=16384, USB_STACK_USE_DEDICATED_RAM=1, FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: ../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F;..\board;../middleware/fatfs/source;../CMSIS/Include;../devices;../platform/drivers;../platform/drivers/common;../rtos/amazon-freertos/lib/include;../rtos/amazon-freertos/lib/include/private;../middleware/usb;../middleware/usb/include;../middleware/usb/osa;../middleware/usb/host;../middleware/usb/host/class;../middleware/fatfs/source;../devices/LPC54608/drivers;../devices/LPC54608;../devices/LPC54608/utilities/str;../devices/LPC54608/utilities/debug_console;../components/uart;../components/serial_manager;../components/lists;..\middleware\emwin\emWin_header;..\middleware\emwin\emWin_Config
  asm define: DEBUG,__CC_ARM,KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC54608J512_flash.scf
  link misc: ../devices/LPC54608/arm/keil_lib_power.lib --remove --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x100" --predefine="-D__usb_use_usbram__=1"
../middleware/emwin/emWin_library/Keil/emWin_M4F.lib
  group doc
    ../board/: readme.txt
  group source
    ../board/: main.c host_msd_fatfs.c fsl_usb_disk_freertos.c
  group app
    ../board/: usb_app.c lcd_app.c key_led_app.c usart_app.c
  group board
    ../board/: board.c clock_config.c pin_mux.c fsl_ft5406.c tsc2046.c
  group usb-host
    ../middleware/usb/host/: usb_host_ip3516hs.c usb_host_ohci.c usb_host_devices.c usb_host_framework.c usb_host_hci.c
  group osa
    ../middleware/usb/osa/: usb_osa_freertos.c
  group amazon-freertos-freertos-portable
    ../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group amazon-freertos-freertos
    ../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group usb-host-class
    ../middleware/usb/host/class/: usb_host_hub.c usb_host_hub_app.c usb_host_msd.c usb_host_msd_ufi.c
  group fatfs-fatfs_source
    ../middleware/fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group drivers
    ../devices/LPC54608/drivers/: fsl_clock.c fsl_common.c fsl_flexcomm.c fsl_gpio.c fsl_emc.c fsl_power.c fsl_reset.c fsl_usart.c fsl_usart_freertos.c fsl_i2c.c fsl_lcdc.c fsl_spi.c
  group device
    ../devices/LPC54608/: system_LPC54608.c
  group startup
    ../devices/LPC54608/arm/: startup_LPC54608.s
  group utilities
    ../devices/LPC54608/utilities/: fsl_assert.c
    ../devices/LPC54608/utilities/debug_console/: fsl_debug_console.c
    ../devices/LPC54608/utilities/str/: fsl_str.c
  group component-uart
    ../components/uart/: usart_adapter.c
  group component-serial_manager
    ../components/serial_manager/: serial_manager.c serial_port_uart.c
  group component-lists
    ../components/lists/: generic_list.c
  group emwin_config
    ../middleware/emwin/emWin_Config/: emwin_config.c
